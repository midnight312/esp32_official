# IAR project test2.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: C:\Users\anhth\OneDrive\Máy tính\do_an_3\test2\driver\inc; C:\Users\anhth\OneDrive\Máy tính\do_an_3\test2; C:\Users\anhth\OneDrive\Máy tính\do_an_3\test2\main\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: test2.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: stm8s_it.c stm8s_it.h
  group driver/inc
    driver/inc/: rf24l01.h stm8s.h stm8s_adc1.h stm8s_awu.h stm8s_beep.h stm8s_can.h stm8s_clk.h stm8s_conf.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_i2c.h stm8s_itc.h stm8s_iwdg.h stm8s_rst.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim4.h stm8s_tim5.h stm8s_tim6.h stm8s_uart1.h stm8s_wwdg.h
  group driver/src
    driver/src/: rf24l01.c stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c
  group main/inc
    main/inc/: main.h
  group main/src
    main/src/: main.c
